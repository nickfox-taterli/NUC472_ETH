# Keil uVision project NUC472.uvprojx, settings and files
target NU472HI8AE (6160000::V6.16::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: NUC472 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\StdDriver\Inc;..\Drivers\Device\Nuvoton\NUC472_442\Include;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\Middlewares\LwIP\src\include;..\Drivers\BSP\ethernetif\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Drivers/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../Core/Src/: main.c app_ethernet.c
    ../Drivers/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Drivers/StdDriver
    ../Drivers/StdDriver/Src/: acmp.c adc.c can.c cap.c clk.c crc.c crypto.c eadc.c ebi.c emac.c epwm.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c rtc.c sc.c scuart.c sd.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group Drivers/BSP/ethernetif
    ../Drivers/BSP/ethernetif/Src/: ethernetif.c sys_arch.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/LWIP/Core
    ../Middlewares/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Middlewares/LWIP/API
    ../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LWIP/netif
    ../Middlewares/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c
  group Middlewares/LWIP/app
    ../Middlewares/LwIP/src/apps/lwiperf/: lwiperf.c
